# Keil uVision project ADC 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADC 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 I2C.c PCF.c ADC 1.c
  group Head Group 1
    ./: I2C.h confi.h PCF.h
